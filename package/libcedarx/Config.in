## package/libcedarx/Config.in
```kconfig
config BR2_PACKAGE_LIBCEDARX
        bool "libcedarx"
        help
          Allwinner video processor support

          http://linux-sunxi.org
```
